# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H750xx, __RTTHREAD__, STM32H7, RT_USING_ARM_LIBC, USE_HAL_DRIVER
  c include: applications;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\port;board\CubeMX_Config\Core\Inc;libraries\drivers;libraries\drivers\include;libraries\drivers\include\config;libraries\touch;.;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;packages\LVGL-latest\src;packages\LVGL-latest\src\core;packages\LVGL-latest\src\draw;packages\LVGL-latest\src\extra;packages\LVGL-latest\src\font;packages\LVGL-latest\src\gpu;packages\LVGL-latest\src\hal;packages\LVGL-latest\src\misc;packages\LVGL-latest\src\widgets;packages\LVGL-latest\src\extra\layouts;packages\LVGL-latest\src\extra\libs;packages\LVGL-latest\src\extra\others;packages\LVGL-latest\src\extra\themes;packages\LVGL-latest\src\extra\widgets;packages\LVGL-latest\src\extra\layouts\flex;packages\LVGL-latest\src\extra\layouts\grid;packages\LVGL-latest\src\extra\libs\bmp;packages\LVGL-latest\src\extra\libs\freetype;packages\LVGL-latest\src\extra\libs\fsdrv;packages\LVGL-latest\src\extra\libs\gif;packages\LVGL-latest\src\extra\libs\png;packages\LVGL-latest\src\extra\libs\qrcode;packages\LVGL-latest\src\extra\libs\rlottie;packages\LVGL-latest\src\extra\libs\sjpg;packages\LVGL-latest\src\extra\others\snapshot;packages\LVGL-latest\src\extra\themes\basic;packages\LVGL-latest\src\extra\themes\default;packages\LVGL-latest\src\extra\themes\mono;packages\LVGL-latest\src\extra\widgets\animimg;packages\LVGL-latest\src\extra\widgets\calendar;packages\LVGL-latest\src\extra\widgets\chart;packages\LVGL-latest\src\extra\widgets\colorwheel;packages\LVGL-latest\src\extra\widgets\imgbtn;packages\LVGL-latest\src\extra\widgets\keyboard;packages\LVGL-latest\src\extra\widgets\led;packages\LVGL-latest\src\extra\widgets\list;packages\LVGL-latest\src\extra\widgets\meter;packages\LVGL-latest\src\extra\widgets\msgbox;packages\LVGL-latest\src\extra\widgets\span;packages\LVGL-latest\src\extra\widgets\spinbox;packages\LVGL-latest\src\extra\widgets\spinner;packages\LVGL-latest\src\extra\widgets\tabview;packages\LVGL-latest\src\extra\widgets\tileview;packages\LVGL-latest\src\extra\widgets\win;packages\LVGL-latest\src\gpu\sdl;libraries\lvgl\demo;libraries\lvgl\demo\src;libraries\lvgl\demo\src\lv_demo_music;libraries\lvgl\demo\src\lv_demo_music\assets;libraries\lvgl;packages\LVGL-latest\rt-thread;libraries\samples;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group Applications
    applications/: main.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    libraries/drivers/: drv_common.c drv_usart.c drv_gpio.c drv_spi.c drv_sdio.c drv_wlan.c drv_sdram.c drv_lcd.c drv_soft_i2c.c
    libraries/touch/: drv_touch.c drv_touch_ft.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group LVGL
    packages/LVGL-latest/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    packages/LVGL-latest/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    packages/LVGL-latest/src/extra/: lv_extra.c
    packages/LVGL-latest/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    packages/LVGL-latest/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_sdl.c lv_gpu_stm32_dma2d.c
    packages/LVGL-latest/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-latest/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    packages/LVGL-latest/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    packages/LVGL-latest/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-latest/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-latest/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-latest/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-latest/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    packages/LVGL-latest/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-latest/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-latest/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-latest/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-latest/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-latest/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-latest/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-latest/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-latest/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-latest/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-latest/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-latest/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-latest/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-latest/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-latest/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-latest/src/extra/widgets/led/: lv_led.c
    packages/LVGL-latest/src/extra/widgets/list/: lv_list.c
    packages/LVGL-latest/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-latest/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-latest/src/extra/widgets/span/: lv_span.c
    packages/LVGL-latest/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-latest/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-latest/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-latest/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-latest/src/extra/widgets/win/: lv_win.c
    packages/LVGL-latest/src/gpu/sdl/: lv_gpu_sdl_draw_arc.c lv_gpu_sdl_draw_blend.c lv_gpu_sdl_draw_img.c lv_gpu_sdl_draw_label.c lv_gpu_sdl_draw_line.c lv_gpu_sdl_draw_rect.c lv_gpu_sdl_lru.c lv_gpu_sdl_mask.c lv_gpu_sdl_stack_blur.c lv_gpu_sdl_texture_cache.c lv_gpu_sdl_utils.c
  group LVGL-demo
    libraries/lvgl/demo/src/lv_demo_music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    libraries/lvgl/demo/src/lv_demo_music/assets/: img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_right.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_3.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_4.c img_lv_demo_music_list_border.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_top.c
  group LVGL-port
    libraries/lvgl/: lv_demo.c lv_port_disp.c lv_port_indev.c
    packages/LVGL-latest/rt-thread/: lv_rt_thread_port.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group Touch
    rt-thread/components/drivers/touch/: touch.c
